# Keil uVision project test.uvproj, settings and files
target test (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: PP01_01_02 +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: USE_FULL_ASSERT_
  c include: .\System;.\App;.\Hwa;.\Driver
  link misc: REMOVEUNUSED
  group System
    ./System/: sys_delay.c sys_tim.c sys_task.c sys_uart.c sys_eeprom.c
  group App
    ./App/: app_brush.c app_config.c app_pulse.c
  group Hwa
    ./Hwa/: hwa_eeprom.c hwa_mifare.c hwa_eeprom_cfg.c
  group Drivers
    ./Driver/: buzzer.c LED.c mifare.c
