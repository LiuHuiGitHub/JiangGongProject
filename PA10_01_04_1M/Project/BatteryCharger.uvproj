# Keil uVision project BatteryCharger.uvproj, settings and files
target BatteryCharger (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: PA10_01 +hex
  c flags: Optimize=9
  c define: USE_FULL_ASSERT_
  c include: ..\App;..\Hwa;..\System
  link misc: REMOVEUNUSED
  group System
    ../System/: sys_adc.c sys_delay.c sys_eeprom.c sys_relay.c sys_task.c sys_uart.c
  group App
    ../App/: app_adc.c app_coin.c app_test.c app_time.c
  group Hwa
    ../Hwa/: drive_tm1640.c drive_tm1650.c hwa_coin.c hwa_key.c hwa_eeprom.c hwa_eeprom_cfg.c hwa_uart.c
