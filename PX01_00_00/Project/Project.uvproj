# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: PX01_00_01 +hex
  c flags: Optimize=9
  c define: USE_FULL_ASSERT_
  c include: ..\App;..\Hwa;..\System
  link misc: REMOVEUNUSED
  group System
    ../System/: sys_delay.c sys_task.c sys_uart.c sys_ccap.c
