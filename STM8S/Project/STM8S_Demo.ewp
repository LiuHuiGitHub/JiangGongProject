# IAR project STM8S_Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\USER; ..\System; ..\Hwa; ..\Driver; ..\App
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S_Demo.hex
  ILINK.IlinkOutputFile: STM8S_Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group App
    ../App/: app_config.c app_test.c
  group Driver
    ../Driver/: drive_led.c drive_scr.c
  group Hwa
    ../Hwa/: hwa_eeprom.c hwa_eeprom_cfg.c hwa_ntc.c
  group System
    ../System/: sys_adc.c sys_eeprom.c sys_iwdg.c sys_task.c sys_vector.c
